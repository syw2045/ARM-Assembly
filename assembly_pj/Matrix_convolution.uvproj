# Keil uVision project Matrix_convolution.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Matrix_convolution
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  group Source Group 1
    ./: Matrix_convolution.s
